<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\CM0\CoreSupport\core_cm0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Startup\IAR\startup_ht6x1x.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\CM0\DeviceSupport\system_ht6xxx.c</name>
    </file>
  </group>
  <group>
    <name>Main</name>
    <file>
      <name>$PROJ_DIR$\..\User\main.c</name>
    </file>
  </group>
  <group>
    <name>StdLibraries</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht501x_emu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht501x_keyscan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6x3x_emu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_aes&amp;rand.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_cmu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_iic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_pmu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_reset.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_tbs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_tdes&amp;rand.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\HT60xx_StdPeriph_Driver\src\ht6xxx_uart&amp;7816.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\User\ATT7022E.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\E2PROM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Flash_Data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\General.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\IEC101.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\initial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Measure.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\power.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Profile.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Ram.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Time.c</name>
    </file>
  </group>
</project>


