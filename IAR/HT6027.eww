<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HT6027.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\&#x8D44;&#x6599;\HT6033_Three - Version1\IAR\&#x5308;&#x7259;&#x5229;HT6x3x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


