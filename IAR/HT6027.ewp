# IAR project HT6027.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HT6X3X Hitrendtech HT6X3X
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HT6x3x
  ICCARM.CCDiagSuppress: Pa089,Pa082
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\CM0\CoreSupport; ..\Libraries\CMSIS\CM0\DeviceSupport; ..\Libraries\HT60xx_StdPeriph_Driver; ..\Libraries\HT60xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HT6027_Line.bin
  ILINK.IlinkOutputFile: HT6027_Line.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../Libraries/Startup/IAR/: startup_ht6x3x.s
    ../Libraries/CMSIS/CM0/DeviceSupport/: system_ht6xxx.c
  group Main
    ../User/: main.c
  group StdLibraries
    ../Libraries/HT60xx_StdPeriph_Driver/src/: ht501x_emu.c ht501x_keyscan.c ht6x3x_emu.c ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_dma.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c
  group User
    ../User/: data.c E2PROM.c Flash_Data.c General.c IEC101.c initial.c interrupt.c power.c Ram.c serial.c Time.c
